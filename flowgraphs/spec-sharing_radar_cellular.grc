options:
  parameters:
    generate_options: qt_gui
    id: spectrum_sharing_cwi_1ue
    output_language: python
    title: SPECTRUM_SHARING_RADAR_CELLULAR
  states: {}

blocks:
- name: basestation_pow
  id: variable_qtgui_range
  parameters:
    start: '0.0'
    step: '0.01'
    stop: '5'
    value: '1'
  states: {state: disabled}
- name: freq_hopping
  id: variable_qtgui_range
  parameters:
    start: '-720e3'
    step: 180e3
    stop: 720e3
    value: 180e3
  states: {state: disabled}
- name: gaussian_pow
  id: variable_qtgui_range
  parameters:
    start: '0.0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {state: disabled}
- name: jammer_power
  id: variable_qtgui_range
  parameters:
    start: '0.0'
    step: '0.01'
    stop: '1'
    value: '0.0'
  states: {state: disabled}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: noise
    min_len: '500'
    start: '0'
    step: 10n
    stop: 100n
    value: '0.00000001'
  states: {state: disabled}
- name: radar_pow
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.001'
    stop: '18'
    value: '0'
  states: {}
- name: radar_pow_var
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.36e6
  states: {}
- name: slow_down_ratio
  id: variable_qtgui_range
  parameters:
    label: Time Slow Down Ratio
    start: '1'
    step: '1'
    stop: '32'
    value: '4'
  states: {state: disabled}
- name: ue1_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE1 Pathloss [dB]
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {state: disabled}
- name: ue2_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE2 Pathloss [dB]
    start: '0'
    step: '1'
    stop: '100'
    value: '10'
  states: {state: disabled}
- name: ue3_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE3 Pathloss [dB]
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {state: disabled}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '1'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: jammer_power
    freq: freq_hopping
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ajchieji/spectrumsharing_4g/radarsamples/radar_scaled_top.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: bypassed}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_path_loss_db/20.0)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_path_loss_db/20.0)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_path_loss_db/20.0)
    type: complex
  states: {state: bypassed}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_path_loss_db/20.0)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_path_loss_db/20.0)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: radar_pow
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 10e6
    fc: 2.56e9
    fftsize: '1024'
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2200
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {state: disabled}
- name: zeromq_rep_sink_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2300
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2301
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {state: disabled}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2201
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_add_xx_0, '0', zeromq_rep_sink_0_1, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', zeromq_rep_sink_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', zeromq_rep_sink_0_2, '0']
- [blocks_multiply_const_vxx_0_1_1, '0', zeromq_rep_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '2']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1_1, '0']
- [zeromq_req_source_0, '0', blocks_throttle_0, '0']
- [zeromq_req_source_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [zeromq_req_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_1_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
